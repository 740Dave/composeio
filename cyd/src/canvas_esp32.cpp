/*
 * canvas_esp32.cpp — ESP32 Canvas backend with band rendering
 *
 * Phase 1b: 16-scanline band buffer replaces the full 150KB framebuffer.
 * Renders the 320-height scene in 20 passes (bands 0-15, 16-31, ..., 304-319).
 * Each pass: clear band, redraw all widgets clipped to band Y range, DMA to display.
 *
 * New in Phase 1b:
 * - Band rendering (render_frame)
 * - draw_line (Bresenham)
 * - stroke_arc (angular iteration)
 * - fill_round_rect / stroke_round_rect
 * - Improved font rendering with generated atlas support (font_atlas.h)
 *
 * Spec: [ED-PHASE1], [CXC-R-DRAW-CONTRACT]
 */

#include "canvas_esp32.h"
#include "cyd_pins.h"

#include <cstring>
#include <cmath>
#include <algorithm>
#include "esp_heap_caps.h"
#include "esp_log.h"
#include "esp_timer.h"

static const char* TAG = "canvas_esp32";

/* -------------------------------------------------------------------
 * Font atlas — generated by fonts/generate_atlas.py
 * If font_atlas.h is not present, fall back to the 8x16 bitmap font.
 * ------------------------------------------------------------------- */
#if __has_include("font_atlas.h")
    #include "font_atlas.h"
    #define HAS_FONT_ATLAS 1
#else
    #define HAS_FONT_ATLAS 0
#endif

/* -------------------------------------------------------------------
 * Minimal hardcoded 8x16 bitmap font (fallback)
 *
 * Covers ASCII 32-126. Each character is 8 pixels wide, 16 pixels tall.
 * Each character is 16 bytes (one byte per row, MSB = leftmost pixel).
 * ------------------------------------------------------------------- */

static const uint8_t font_8x16[95][16] = {
    /* 32: space */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 33: ! */
    {0x00,0x00,0x18,0x3C,0x3C,0x3C,0x18,0x18,0x18,0x00,0x18,0x18,0x00,0x00,0x00,0x00},
    /* 34: " */
    {0x00,0x66,0x66,0x66,0x24,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 35: # */
    {0x00,0x00,0x00,0x6C,0x6C,0xFE,0x6C,0x6C,0x6C,0xFE,0x6C,0x6C,0x00,0x00,0x00,0x00},
    /* 36: $ */
    {0x00,0x10,0x10,0x7C,0xD6,0xD0,0x7C,0x16,0x16,0xD6,0x7C,0x10,0x10,0x00,0x00,0x00},
    /* 37: % */
    {0x00,0x00,0x00,0x00,0xC2,0xC6,0x0C,0x18,0x30,0x60,0xC6,0x86,0x00,0x00,0x00,0x00},
    /* 38: & */
    {0x00,0x00,0x38,0x6C,0x6C,0x38,0x76,0xDC,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00},
    /* 39: ' */
    {0x00,0x30,0x30,0x30,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 40: ( */
    {0x00,0x00,0x0C,0x18,0x30,0x30,0x30,0x30,0x30,0x30,0x18,0x0C,0x00,0x00,0x00,0x00},
    /* 41: ) */
    {0x00,0x00,0x30,0x18,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x18,0x30,0x00,0x00,0x00,0x00},
    /* 42: * */
    {0x00,0x00,0x00,0x00,0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 43: + */
    {0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x7E,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 44: , */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x18,0x30,0x00,0x00,0x00},
    /* 45: - */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 46: . */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00},
    /* 47: / */
    {0x00,0x00,0x00,0x00,0x02,0x06,0x0C,0x18,0x30,0x60,0xC0,0x80,0x00,0x00,0x00,0x00},
    /* 48: 0 */
    {0x00,0x00,0x7C,0xC6,0xC6,0xCE,0xDE,0xF6,0xE6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 49: 1 */
    {0x00,0x00,0x18,0x38,0x78,0x18,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00},
    /* 50: 2 */
    {0x00,0x00,0x7C,0xC6,0x06,0x0C,0x18,0x30,0x60,0xC0,0xC6,0xFE,0x00,0x00,0x00,0x00},
    /* 51: 3 */
    {0x00,0x00,0x7C,0xC6,0x06,0x06,0x3C,0x06,0x06,0x06,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 52: 4 */
    {0x00,0x00,0x0C,0x1C,0x3C,0x6C,0xCC,0xFE,0x0C,0x0C,0x0C,0x1E,0x00,0x00,0x00,0x00},
    /* 53: 5 */
    {0x00,0x00,0xFE,0xC0,0xC0,0xC0,0xFC,0x06,0x06,0x06,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 54: 6 */
    {0x00,0x00,0x38,0x60,0xC0,0xC0,0xFC,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 55: 7 */
    {0x00,0x00,0xFE,0xC6,0x06,0x06,0x0C,0x18,0x30,0x30,0x30,0x30,0x00,0x00,0x00,0x00},
    /* 56: 8 */
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0x7C,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 57: 9 */
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0x7E,0x06,0x06,0x06,0x0C,0x78,0x00,0x00,0x00,0x00},
    /* 58: : */
    {0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x00},
    /* 59: ; */
    {0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x18,0x18,0x30,0x00,0x00,0x00,0x00},
    /* 60: < */
    {0x00,0x00,0x00,0x06,0x0C,0x18,0x30,0x60,0x30,0x18,0x0C,0x06,0x00,0x00,0x00,0x00},
    /* 61: = */
    {0x00,0x00,0x00,0x00,0x00,0x7E,0x00,0x00,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 62: > */
    {0x00,0x00,0x00,0x60,0x30,0x18,0x0C,0x06,0x0C,0x18,0x30,0x60,0x00,0x00,0x00,0x00},
    /* 63: ? */
    {0x00,0x00,0x7C,0xC6,0xC6,0x0C,0x18,0x18,0x18,0x00,0x18,0x18,0x00,0x00,0x00,0x00},
    /* 64: @ */
    {0x00,0x00,0x00,0x7C,0xC6,0xC6,0xDE,0xDE,0xDE,0xDC,0xC0,0x7C,0x00,0x00,0x00,0x00},
    /* 65: A */
    {0x00,0x00,0x10,0x38,0x6C,0xC6,0xC6,0xFE,0xC6,0xC6,0xC6,0xC6,0x00,0x00,0x00,0x00},
    /* 66: B */
    {0x00,0x00,0xFC,0x66,0x66,0x66,0x7C,0x66,0x66,0x66,0x66,0xFC,0x00,0x00,0x00,0x00},
    /* 67: C */
    {0x00,0x00,0x3C,0x66,0xC2,0xC0,0xC0,0xC0,0xC0,0xC2,0x66,0x3C,0x00,0x00,0x00,0x00},
    /* 68: D */
    {0x00,0x00,0xF8,0x6C,0x66,0x66,0x66,0x66,0x66,0x66,0x6C,0xF8,0x00,0x00,0x00,0x00},
    /* 69: E */
    {0x00,0x00,0xFE,0x66,0x62,0x68,0x78,0x68,0x60,0x62,0x66,0xFE,0x00,0x00,0x00,0x00},
    /* 70: F */
    {0x00,0x00,0xFE,0x66,0x62,0x68,0x78,0x68,0x60,0x60,0x60,0xF0,0x00,0x00,0x00,0x00},
    /* 71: G */
    {0x00,0x00,0x3C,0x66,0xC2,0xC0,0xC0,0xDE,0xC6,0xC6,0x66,0x3A,0x00,0x00,0x00,0x00},
    /* 72: H */
    {0x00,0x00,0xC6,0xC6,0xC6,0xC6,0xFE,0xC6,0xC6,0xC6,0xC6,0xC6,0x00,0x00,0x00,0x00},
    /* 73: I */
    {0x00,0x00,0x3C,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00},
    /* 74: J */
    {0x00,0x00,0x1E,0x0C,0x0C,0x0C,0x0C,0x0C,0xCC,0xCC,0xCC,0x78,0x00,0x00,0x00,0x00},
    /* 75: K */
    {0x00,0x00,0xE6,0x66,0x66,0x6C,0x78,0x78,0x6C,0x66,0x66,0xE6,0x00,0x00,0x00,0x00},
    /* 76: L */
    {0x00,0x00,0xF0,0x60,0x60,0x60,0x60,0x60,0x60,0x62,0x66,0xFE,0x00,0x00,0x00,0x00},
    /* 77: M */
    {0x00,0x00,0xC6,0xEE,0xFE,0xFE,0xD6,0xC6,0xC6,0xC6,0xC6,0xC6,0x00,0x00,0x00,0x00},
    /* 78: N */
    {0x00,0x00,0xC6,0xE6,0xF6,0xFE,0xDE,0xCE,0xC6,0xC6,0xC6,0xC6,0x00,0x00,0x00,0x00},
    /* 79: O */
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 80: P */
    {0x00,0x00,0xFC,0x66,0x66,0x66,0x7C,0x60,0x60,0x60,0x60,0xF0,0x00,0x00,0x00,0x00},
    /* 81: Q */
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xD6,0xDE,0x7C,0x0C,0x0E,0x00,0x00},
    /* 82: R */
    {0x00,0x00,0xFC,0x66,0x66,0x66,0x7C,0x6C,0x66,0x66,0x66,0xE6,0x00,0x00,0x00,0x00},
    /* 83: S */
    {0x00,0x00,0x7C,0xC6,0xC6,0x60,0x38,0x0C,0x06,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 84: T */
    {0x00,0x00,0xFF,0xDB,0x99,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00},
    /* 85: U */
    {0x00,0x00,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 86: V */
    {0x00,0x00,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0x6C,0x38,0x10,0x00,0x00,0x00,0x00},
    /* 87: W */
    {0x00,0x00,0xC6,0xC6,0xC6,0xC6,0xD6,0xD6,0xD6,0xFE,0xEE,0x6C,0x00,0x00,0x00,0x00},
    /* 88: X */
    {0x00,0x00,0xC6,0xC6,0x6C,0x7C,0x38,0x38,0x7C,0x6C,0xC6,0xC6,0x00,0x00,0x00,0x00},
    /* 89: Y */
    {0x00,0x00,0xC3,0xC3,0x66,0x3C,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00},
    /* 90: Z */
    {0x00,0x00,0xFE,0xC6,0x86,0x0C,0x18,0x30,0x60,0xC2,0xC6,0xFE,0x00,0x00,0x00,0x00},
    /* 91: [ */
    {0x00,0x00,0x3C,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x3C,0x00,0x00,0x00,0x00},
    /* 92: \ */
    {0x00,0x00,0x00,0x80,0xC0,0xE0,0x70,0x38,0x1C,0x0E,0x06,0x02,0x00,0x00,0x00,0x00},
    /* 93: ] */
    {0x00,0x00,0x3C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x3C,0x00,0x00,0x00,0x00},
    /* 94: ^ */
    {0x10,0x38,0x6C,0xC6,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 95: _ */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0x00,0x00},
    /* 96: ` */
    {0x00,0x30,0x18,0x0C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 97: a */
    {0x00,0x00,0x00,0x00,0x00,0x78,0x0C,0x7C,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00},
    /* 98: b */
    {0x00,0x00,0xE0,0x60,0x60,0x78,0x6C,0x66,0x66,0x66,0x66,0x7C,0x00,0x00,0x00,0x00},
    /* 99: c */
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0xC0,0xC0,0xC0,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 100: d */
    {0x00,0x00,0x1C,0x0C,0x0C,0x3C,0x6C,0xCC,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00},
    /* 101: e */
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0xFE,0xC0,0xC0,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 102: f */
    {0x00,0x00,0x1C,0x36,0x32,0x30,0x78,0x30,0x30,0x30,0x30,0x78,0x00,0x00,0x00,0x00},
    /* 103: g */
    {0x00,0x00,0x00,0x00,0x00,0x76,0xCC,0xCC,0xCC,0xCC,0xCC,0x7C,0x0C,0xCC,0x78,0x00},
    /* 104: h */
    {0x00,0x00,0xE0,0x60,0x60,0x6C,0x76,0x66,0x66,0x66,0x66,0xE6,0x00,0x00,0x00,0x00},
    /* 105: i */
    {0x00,0x00,0x18,0x18,0x00,0x38,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00},
    /* 106: j */
    {0x00,0x00,0x06,0x06,0x00,0x0E,0x06,0x06,0x06,0x06,0x06,0x06,0x66,0x66,0x3C,0x00},
    /* 107: k */
    {0x00,0x00,0xE0,0x60,0x60,0x66,0x6C,0x78,0x78,0x6C,0x66,0xE6,0x00,0x00,0x00,0x00},
    /* 108: l */
    {0x00,0x00,0x38,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00},
    /* 109: m */
    {0x00,0x00,0x00,0x00,0x00,0xEC,0xFE,0xD6,0xD6,0xD6,0xD6,0xC6,0x00,0x00,0x00,0x00},
    /* 110: n */
    {0x00,0x00,0x00,0x00,0x00,0xDC,0x66,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00,0x00},
    /* 111: o */
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 112: p */
    {0x00,0x00,0x00,0x00,0x00,0xDC,0x66,0x66,0x66,0x66,0x66,0x7C,0x60,0x60,0xF0,0x00},
    /* 113: q */
    {0x00,0x00,0x00,0x00,0x00,0x76,0xCC,0xCC,0xCC,0xCC,0xCC,0x7C,0x0C,0x0C,0x1E,0x00},
    /* 114: r */
    {0x00,0x00,0x00,0x00,0x00,0xDC,0x76,0x66,0x60,0x60,0x60,0xF0,0x00,0x00,0x00,0x00},
    /* 115: s */
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0x60,0x38,0x0C,0xC6,0x7C,0x00,0x00,0x00,0x00},
    /* 116: t */
    {0x00,0x00,0x10,0x30,0x30,0xFC,0x30,0x30,0x30,0x30,0x36,0x1C,0x00,0x00,0x00,0x00},
    /* 117: u */
    {0x00,0x00,0x00,0x00,0x00,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00},
    /* 118: v */
    {0x00,0x00,0x00,0x00,0x00,0xC3,0xC3,0xC3,0xC3,0x66,0x3C,0x18,0x00,0x00,0x00,0x00},
    /* 119: w */
    {0x00,0x00,0x00,0x00,0x00,0xC6,0xC6,0xC6,0xD6,0xD6,0xFE,0x6C,0x00,0x00,0x00,0x00},
    /* 120: x */
    {0x00,0x00,0x00,0x00,0x00,0xC6,0x6C,0x38,0x38,0x38,0x6C,0xC6,0x00,0x00,0x00,0x00},
    /* 121: y */
    {0x00,0x00,0x00,0x00,0x00,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0x7E,0x06,0x0C,0xF8,0x00},
    /* 122: z */
    {0x00,0x00,0x00,0x00,0x00,0xFE,0xCC,0x18,0x30,0x60,0xC6,0xFE,0x00,0x00,0x00,0x00},
    /* 123: { */
    {0x00,0x00,0x0E,0x18,0x18,0x18,0x70,0x18,0x18,0x18,0x18,0x0E,0x00,0x00,0x00,0x00},
    /* 124: | */
    {0x00,0x00,0x18,0x18,0x18,0x18,0x00,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00},
    /* 125: } */
    {0x00,0x00,0x70,0x18,0x18,0x18,0x0E,0x18,0x18,0x18,0x18,0x70,0x00,0x00,0x00,0x00},
    /* 126: ~ */
    {0x00,0x00,0x76,0xDC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
};

static constexpr int kFontW = 8;
static constexpr int kFontH = 16;
static constexpr int kFontFirstChar = 32;
static constexpr int kFontLastChar = 126;

/* -------------------------------------------------------------------
 * RGB565 conversion and pixel operations
 * ------------------------------------------------------------------- */

uint16_t ESP32Canvas::rgb565_be(uint8_t r, uint8_t g, uint8_t b) {
    uint16_t c = ((r & 0xF8) << 8) | ((g & 0xFC) << 3) | (b >> 3);
    return (c >> 8) | (c << 8);
}

static inline void unpack_rgb565_be(uint16_t pixel, uint8_t& r, uint8_t& g, uint8_t& b) {
    uint16_t c = (pixel >> 8) | (pixel << 8);
    r = (c >> 8) & 0xF8; r |= r >> 5;
    g = (c >> 3) & 0xFC; g |= g >> 6;
    b = (c << 3) & 0xF8; b |= b >> 5;
}

void ESP32Canvas::put_pixel(int x, int y, uint8_t r, uint8_t g, uint8_t b, uint8_t a) {
    /* Bounds check — scene coordinates */
    if (x < 0 || x >= _width) return;
    if (!in_band(y)) return;

    /* Global opacity multiplier (set_opacity) */
    if (_state.opacity < 0.999f) {
        a = (uint8_t)(a * _state.opacity + 0.5f);
        if (a == 0) return;
    }

    /* Clip region check (scene coordinates) */
    if (_state.has_clip) {
        if (x < (int)_state.clip_x || x >= (int)(_state.clip_x + _state.clip_w) ||
            y < (int)_state.clip_y || y >= (int)(_state.clip_y + _state.clip_h)) {
            return;
        }
        /* Rounded clip: additionally reject the corner regions outside
         * the arc (clip_round_rect — the gauge bar fill's rounded
         * bottom corners). */
        if (_state.clip_radius > 0.0f && !in_clip_round(x, y)) return;
    }

    /* Convert to band-local Y */
    int band_local_y = y - _band_y;
    int idx = band_local_y * _width + x;

    if (a == 255) {
        _band_buf[idx] = rgb565_be(r, g, b);
    } else if (a == 0) {
        return;
    } else {
        uint8_t dr, dg, db;
        unpack_rgb565_be(_band_buf[idx], dr, dg, db);

        uint16_t inv_a = 255 - a;
        r = (uint8_t)((r * a + dr * inv_a + 127) / 255);
        g = (uint8_t)((g * a + dg * inv_a + 127) / 255);
        b = (uint8_t)((b * a + db * inv_a + 127) / 255);

        _band_buf[idx] = rgb565_be(r, g, b);
    }
}

/* -------------------------------------------------------------------
 * Gradient evaluation
 * ------------------------------------------------------------------- */

static inline void lerp_color(const GradientStop& a, const GradientStop& b,
                               float t,
                               uint8_t& r, uint8_t& g, uint8_t& bb, uint8_t& aa) {
    r = (uint8_t)(a.r + (b.r - a.r) * t);
    g = (uint8_t)(a.g + (b.g - a.g) * t);
    bb = (uint8_t)(a.b + (b.b - a.b) * t);
    aa = (uint8_t)(a.a + (b.a - a.a) * t);
}

void ESP32Canvas::resolve_fill_color(float px, float py,
                                      uint8_t& r, uint8_t& g, uint8_t& b, uint8_t& a) const {
    if (_state.grad_type == GradientType::None) {
        r = _state.fill_r;
        g = _state.fill_g;
        b = _state.fill_b;
        a = _state.fill_a;
        return;
    }

    float t = 0.0f;

    if (_state.grad_type == GradientType::Radial) {
        float dx = px - _state.grad_cx;
        float dy = py - _state.grad_cy;
        float dist = sqrtf(dx * dx + dy * dy);
        t = (_state.grad_r > 0.0f) ? (dist / _state.grad_r) : 1.0f;
    } else {
        float dx = _state.grad_x2 - _state.grad_x1;
        float dy = _state.grad_y2 - _state.grad_y1;
        float len2 = dx * dx + dy * dy;
        if (len2 > 0.0001f) {
            t = ((px - _state.grad_x1) * dx + (py - _state.grad_y1) * dy) / len2;
        }
    }

    if (t < 0.0f) t = 0.0f;
    if (t > 1.0f) t = 1.0f;

    int n = _state.grad_stop_count;
    if (n <= 0) {
        r = _state.fill_r; g = _state.fill_g; b = _state.fill_b; a = _state.fill_a;
        return;
    }
    if (n == 1 || t <= _state.grad_stops[0].offset) {
        r = _state.grad_stops[0].r; g = _state.grad_stops[0].g;
        b = _state.grad_stops[0].b; a = _state.grad_stops[0].a;
        return;
    }
    if (t >= _state.grad_stops[n - 1].offset) {
        r = _state.grad_stops[n - 1].r; g = _state.grad_stops[n - 1].g;
        b = _state.grad_stops[n - 1].b; a = _state.grad_stops[n - 1].a;
        return;
    }

    for (int i = 0; i < n - 1; i++) {
        if (t >= _state.grad_stops[i].offset && t <= _state.grad_stops[i + 1].offset) {
            float range = _state.grad_stops[i + 1].offset - _state.grad_stops[i].offset;
            float local_t = (range > 0.0001f) ? (t - _state.grad_stops[i].offset) / range : 0.0f;
            lerp_color(_state.grad_stops[i], _state.grad_stops[i + 1], local_t, r, g, b, a);
            return;
        }
    }

    r = _state.grad_stops[n - 1].r; g = _state.grad_stops[n - 1].g;
    b = _state.grad_stops[n - 1].b; a = _state.grad_stops[n - 1].a;
}

/* -------------------------------------------------------------------
 * Horizontal line fills (clipped to current band)
 * ------------------------------------------------------------------- */

void ESP32Canvas::fill_hline(int x0, int x1, int y,
                              uint8_t r, uint8_t g, uint8_t b, uint8_t a) {
    /* Scene-coordinate Y — skip if not in current band */
    if (!in_band(y)) return;

    /* Apply clip */
    if (_state.has_clip) {
        int cl = (int)_state.clip_x;
        int cr = (int)(_state.clip_x + _state.clip_w);
        if (y < (int)_state.clip_y || y >= (int)(_state.clip_y + _state.clip_h)) return;
        if (x0 < cl) x0 = cl;
        if (x1 >= cr) x1 = cr - 1;
    }

    if (x0 < 0) x0 = 0;
    if (x1 >= _width) x1 = _width - 1;
    if (x0 > x1) return;

    int band_local_y = y - _band_y;

    /* Rounded clip forces the per-pixel path (put_pixel owns the
     * corner-arc SDF test); the fast row-fill can't express it. */
    bool round_clip = _state.has_clip && _state.clip_radius > 0.0f;

    if (a == 255 && _state.opacity >= 0.999f && !round_clip) {
        uint16_t c = rgb565_be(r, g, b);
        uint16_t* row = _band_buf + band_local_y * _width;
        for (int x = x0; x <= x1; x++) {
            row[x] = c;
        }
    } else if (a > 0) {
        /* put_pixel applies the opacity multiplier exactly once */
        for (int x = x0; x <= x1; x++) {
            put_pixel(x, y, r, g, b, a);
        }
    }
}

void ESP32Canvas::fill_hline_gradient(int x0, int x1, int y) {
    if (!in_band(y)) return;

    if (_state.has_clip) {
        int cl = (int)_state.clip_x;
        int cr = (int)(_state.clip_x + _state.clip_w);
        if (y < (int)_state.clip_y || y >= (int)(_state.clip_y + _state.clip_h)) return;
        if (x0 < cl) x0 = cl;
        if (x1 >= cr) x1 = cr - 1;
    }

    if (x0 < 0) x0 = 0;
    if (x1 >= _width) x1 = _width - 1;
    if (x0 > x1) return;

    bool round_clip = _state.has_clip && _state.clip_radius > 0.0f;
    for (int x = x0; x <= x1; x++) {
        uint8_t r, g, b, a;
        resolve_fill_color((float)x + 0.5f, (float)y + 0.5f, r, g, b, a);
        if (a == 255 && _state.opacity >= 0.999f && !round_clip) {
            int band_local_y = y - _band_y;
            _band_buf[band_local_y * _width + x] = rgb565_be(r, g, b);
        } else if (a > 0) {
            put_pixel(x, y, r, g, b, a);
        }
    }
}

/* -------------------------------------------------------------------
 * Band buffer management
 * ------------------------------------------------------------------- */

void ESP32Canvas::clear_band(uint8_t r, uint8_t g, uint8_t b) {
    /* Clears the ACTIVE ROW WINDOW only — on the band tier that is the
     * whole buffer (window == band), on the frame tier it is the dirty
     * span, and clearing outside it would erase live pixels the caller
     * never asked to repaint. */
    uint16_t c = rgb565_be(r, g, b);
    uint16_t* p = _band_buf + (size_t)(_row_lo - _band_y) * _width;
    int total = (_row_hi - _row_lo + 1) * _width;
    for (int i = 0; i < total; i++) {
        p[i] = c;
    }
}

/* -------------------------------------------------------------------
 * Surface management
 * ------------------------------------------------------------------- */

ESP32Canvas::~ESP32Canvas() {
    if (_band_buf) {
        heap_caps_free(_band_buf);
        _band_buf = nullptr;
    }
#ifdef CXC_DAMAGE_AUDIT
    if (_row_crc) {
        free(_row_crc);
        _row_crc = nullptr;
    }
#endif
}

void ESP32Canvas::create_surface(int width, int height) {
    _width = width;
    _height = height;

    /* Allocate band buffer: width * kBandHeight * 2 bytes in DMA-capable SRAM */
    size_t band_size = width * kBandHeight * sizeof(uint16_t);

    /* Where the buffer lives depends on how big it is.
     *
     * A 16-scanline band (the no-PSRAM floor) belongs in internal
     * DMA-capable SRAM — small, and the DMA reaches it directly.  A
     * FULL-FRAME band (a PSRAM board — [CXC-BRINGUP]) is 150 KB+, and
     * taking that from the internal DMA heap would starve WiFi long
     * before it helped rendering.  So the large case asks for PSRAM
     * FIRST and only falls back to internal.
     *
     * The S3's GDMA can reach PSRAM; a driver whose DMA cannot must
     * stage through its own bounce buffer rather than silently ACK a
     * dead panel (boards/hosyond_s3.cpp does exactly that). */
    static constexpr size_t kPreferPsramAbove = 32768;

    if (band_size > kPreferPsramAbove) {
        _band_buf = static_cast<uint16_t*>(
            heap_caps_malloc(band_size, MALLOC_CAP_SPIRAM));
        if (_band_buf) {
            ESP_LOGI(TAG, "band buffer (%zu bytes) placed in PSRAM", band_size);
        }
    }
    if (!_band_buf) {
        _band_buf = static_cast<uint16_t*>(
            heap_caps_malloc(band_size, MALLOC_CAP_DMA));
    }

    if (!_band_buf) {
        ESP_LOGE(TAG, "Failed to allocate %zu byte band buffer", band_size);
        return;
    }

    memset(_band_buf, 0, band_size);

#ifdef CXC_DAMAGE_AUDIT
    /* Per-scanline CRC of what was last SENT (audit_rows).  4 B/row —
     * 1,280 B on a 320-row panel.  A failed allocation degrades the
     * audit to "unavailable", never the rendering. */
    _row_crc = static_cast<uint32_t*>(calloc((size_t)height, sizeof(uint32_t)));
    ESP_LOGW(TAG, "[CXC-ER-DAMAGE] row-CRC damage audit %s (%d rows)",
             _row_crc ? "ARMED" : "UNAVAILABLE (alloc failed)", height);
#endif

    /* Initialize graphics state */
    memset(&_state, 0, sizeof(_state));
    _state.fill_r = 0; _state.fill_g = 0; _state.fill_b = 0; _state.fill_a = 255;
    _state.stroke_r = 255; _state.stroke_g = 255; _state.stroke_b = 255; _state.stroke_a = 255;
    _state.stroke_width = 1.0f;
    _state.has_clip = false;
    _state.grad_type = GradientType::None;
    _state.has_shadow = false;
    _state.font_size = 16.0f;
    _state.font_bold = false;
    _state.font_commp = false;
    _state.opacity = 1.0f;
    _state_depth = 0;
    _band_y = 0;
    _row_lo = 0;
    _row_hi = kBandHeight - 1;

    /* The buffer holds the whole panel -> it PERSISTS between renders,
     * which is what makes a sub-frame dirty repaint possible without
     * re-rasterising or re-transferring the frame. */
    _full_frame = (kBandHeight >= _height);

    ESP_LOGI(TAG, "Band-rendered surface: %dx%d, band=%d scanlines, buffer=%zu bytes",
             width, height, kBandHeight, band_size);
    ESP_LOGI(TAG, "Dirty quantum: %d rows/band, %d bands, repaint mode: %s",
             kDirtyBandHeight,
             (_height + kDirtyBandHeight - 1) / kDirtyBandHeight,
             _full_frame ? "in-place row span (persistent frame buffer)"
                         : "band walk");
}

void ESP32Canvas::present() {
    /* In band rendering mode, present() is a no-op.
     * Use render_frame() to iterate all bands and transfer to display. */
}

Size ESP32Canvas::get_surface_size() {
    return Size{(float)_width, (float)_height};
}

/* -------------------------------------------------------------------
 * Band rendering — the core Phase 1b architecture
 * ------------------------------------------------------------------- */

void ESP32Canvas::render_frame(DrawCallback draw_fn, void* user_data) {
    render_rows(draw_fn, user_data, 0, _height - 1);
}

void ESP32Canvas::render_bands(DrawCallback draw_fn, void* user_data,
                               int band_first, int band_last) {
    int num_bands = (_height + kDirtyBandHeight - 1) / kDirtyBandHeight;
    if (band_first < 0) band_first = 0;
    if (band_last >= num_bands) band_last = num_bands - 1;
    if (band_first > band_last) return;

    render_rows(draw_fn, user_data,
                band_first * kDirtyBandHeight,
                (band_last + 1) * kDirtyBandHeight - 1);
}

void ESP32Canvas::render_rows(DrawCallback draw_fn, void* user_data,
                              int y0, int y1, bool bottom_up) {
    if (!_display || !_band_buf) return;
    if (y0 < 0) y0 = 0;
    if (y1 >= _height) y1 = _height - 1;
    if (y0 > y1) return;

    _last_rows = 0;
    _last_draw_us = 0;
    _last_xfer_us = 0;

    if (_full_frame) {
        /* One transfer, one wavefront — direction is meaningless. */
        (void)bottom_up;
        /* FRAME TIER — the buffer IS the frame and it persists between
         * renders, so a dirty repaint re-rasterises the span IN PLACE at
         * its true offsets and transfers only those rows.  ONE scene
         * pass regardless of span height (the whole point of the
         * full-framebuffer call), and transfer_band already documents
         * band_buf as starting at y_start, so the row pointer needs no
         * seam change.  [CXC-ER-RENDER] on the frame tier. */
        _band_y = 0;
        _row_lo = y0;
        _row_hi = y1;

        int64_t t_draw = esp_timer_get_time();
        /* Clear only the dirty rows — identical semantics to the band
         * tier's per-band memset, restricted to the window. */
        memset(_band_buf + (size_t)y0 * _width, 0,
               (size_t)(y1 - y0 + 1) * _width * sizeof(uint16_t));
        reset_draw_state();
        draw_fn(*this, user_data);
        _last_draw_us = esp_timer_get_time() - t_draw;

        int64_t t_xfer = esp_timer_get_time();
        _display->transfer_band(_band_buf + (size_t)y0 * _width,
                                (uint16_t)y0, (uint16_t)y1);
        _last_xfer_us = esp_timer_get_time() - t_xfer;

        /* Leave the window open on the whole frame: any drawing that
         * happens outside a render call (there is none today, but the
         * capture server draws through this canvas) must not be gated
         * by a stale dirty span. */
        _row_lo = 0;
        _row_hi = _height - 1;
        _last_rows = y1 - y0 + 1;
        return;
    }

    /* BAND TIER (the classic CYD floor): the buffer holds kBandHeight
     * rows, so the span is walked band by band and the scene is redrawn
     * once per band.
     *
     * The span is CLAMPED INTO each band ([CXC-ER-DAMAGE]): a caller
     * asking for rows 269..291 rasterises and transfers 23 rows, not
     * the 32 rows of the two bands they land in.  For a band-ALIGNED
     * span this is arithmetically inert — lo == _band_y and hi ==
     * band end — which is every caller that predates dirty row spans
     * (render_frame passes 0..height-1; render_bands passes whole
     * multiples of kDirtyBandHeight == kBandHeight).  Drawing cost
     * still scales with BANDS walked, because a band is one scene
     * pass; transfer cost now scales with ROWS, which is the 73% of a
     * repaint that this exists to cut. */
    int b0 = y0 / kBandHeight;
    int b1 = y1 / kBandHeight;

    /* Walk direction is presentation only — every band sets its own
     * address window, so a descending walk lands the identical pixels
     * ([CXC-ER-DAMAGE] paint-order). */
    for (int step = 0; step <= b1 - b0; step++) {
        int band = bottom_up ? (b1 - step) : (b0 + step);
        _band_y = band * kBandHeight;
        int lo = _band_y > y0 ? _band_y : y0;
        int hi = _band_y + kBandHeight - 1;
        if (hi > y1) hi = y1;
        if (hi >= _height) hi = _height - 1;
        if (lo > hi) continue;
        _row_lo = lo;
        _row_hi = hi;

        int64_t t_draw = esp_timer_get_time();

        /* Clear the ACTIVE ROWS to black.  Rows of the buffer outside
         * the window keep whatever the previous band left there and are
         * never transferred — the same contract clear_band() honours. */
        uint16_t* rows = _band_buf + (size_t)(lo - _band_y) * _width;
        size_t row_count = (size_t)(hi - lo + 1);
        memset(rows, 0, row_count * _width * sizeof(uint16_t));

        /* Reset graphics state for each band */
        reset_draw_state();

        /* Call the draw function — it redraws everything.
         * Drawing ops auto-clip to the window via put_pixel/fill_hline. */
        draw_fn(*this, user_data);
        _last_draw_us += esp_timer_get_time() - t_draw;

        /* Transfer the active rows to display */
        int64_t t_xfer = esp_timer_get_time();
        _display->transfer_band(rows, (uint16_t)lo, (uint16_t)hi);
        int64_t xfer_us = esp_timer_get_time() - t_xfer;
        _last_xfer_us += xfer_us;
        _last_rows += (int)row_count;

#ifdef CXC_XFER_TRACE
        /* Per-band cost, for judging whether a multi-band repaint is a
         * WIRE cost or a per-transfer OVERHEAD cost.  The distinction
         * decides whether coalescing contiguous bands into one address
         * window can help ([CXC-ER-DAMAGE] paint-order finding). */
        ESP_LOGW(TAG, "[XFER] band %2d rows %3d..%3d (%2d) draw %5.2f ms "
                 "xfer %5.2f ms  t=%lld", band, lo, hi, (int)row_count,
                 (esp_timer_get_time() - t_draw - xfer_us) / 1000.0f,
                 xfer_us / 1000.0f,
                 (long long)(esp_timer_get_time() / 1000));
#endif

#ifdef CXC_DAMAGE_AUDIT
        /* Every row that reaches the panel is recorded — this is the
         * ONLY place the audit table is written, so it cannot drift
         * from what was actually sent. */
        if (_row_crc)
            for (int y = lo; y <= hi; y++) _row_crc[y] = row_crc(y);
#endif
    }
}

#ifdef CXC_DAMAGE_AUDIT
/* FNV-1a over one full scanline of the band buffer, in scene Y. */
uint32_t ESP32Canvas::row_crc(int y) const {
    if (!_band_buf || y < _row_lo || y > _row_hi) return 0;
    const uint8_t* p = reinterpret_cast<const uint8_t*>(
        _band_buf + (size_t)(y - _band_y) * _width);
    uint32_t h = 2166136261u;
    size_t n = (size_t)_width * sizeof(uint16_t);
    for (size_t i = 0; i < n; i++) {
        h ^= p[i];
        h *= 16777619u;
    }
    return h;
}

int ESP32Canvas::audit_rows(DrawCallback draw_fn, void* user_data,
                            int* first_bad) {
    if (first_bad) *first_bad = -1;
    if (!_band_buf || !_row_crc || !draw_fn) return -1;

    int bad = 0;
    int saved_lo = _row_lo, saved_hi = _row_hi, saved_band = _band_y;

    if (_full_frame) {
        /* The buffer already IS what was sent; re-render into a scratch
         * window is not possible without a second frame of RAM, so the
         * frame tier audits by re-rendering in place and comparing —
         * which would destroy the very thing it is checking.  Refuse
         * rather than pretend. */
        return -1;
    }

    for (int band = 0; band * kBandHeight < _height; band++) {
        _band_y = band * kBandHeight;
        _row_lo = _band_y;
        _row_hi = _band_y + kBandHeight - 1;
        if (_row_hi >= _height) _row_hi = _height - 1;

        memset(_band_buf, 0, (size_t)_width * kBandHeight * sizeof(uint16_t));
        reset_draw_state();
        draw_fn(*this, user_data);

        for (int y = _row_lo; y <= _row_hi; y++) {
            if (row_crc(y) == _row_crc[y]) continue;
            if (bad == 0 && first_bad) *first_bad = y;
            bad++;
        }
    }

    _band_y = saved_band;
    _row_lo = saved_lo;
    _row_hi = saved_hi;
    return bad;
}
#endif

void ESP32Canvas::reset_draw_state() {
    memset(&_state, 0, sizeof(_state));
    _state.fill_a = 255;
    _state.stroke_r = 255; _state.stroke_g = 255; _state.stroke_b = 255;
    _state.stroke_a = 255;
    _state.stroke_width = 1.0f;
    _state.font_size = 16.0f;
    _state.font_bold = false;
    _state.font_commp = false;
    _state.opacity = 1.0f;
    _state_depth = 0;
}

/* -------------------------------------------------------------------
 * Drawing primitives
 * ------------------------------------------------------------------- */

void ESP32Canvas::fill_rect(float x, float y, float w, float h) {
    /* Exact floating-point boundaries */
    float x0f = x, y0f = y, x1f = x + w, y1f = y + h;

    /* Integer pixel range covering the rect */
    int py0 = (int)floorf(y0f);
    int py1 = (int)ceilf(y1f) - 1;
    int px0 = (int)floorf(x0f);
    int px1 = (int)ceilf(x1f) - 1;

    /* Early band rejection */
    if (py1 < _row_lo || py0 > _row_hi) return;

    bool use_gradient = (_state.grad_type != GradientType::None);
    uint8_t fr = _state.fill_r, fg = _state.fill_g;
    uint8_t fb = _state.fill_b, fa = _state.fill_a;

    /* Precompute edge coverage values */
    float left_cov  = (float)(px0 + 1) - x0f;  /* coverage of leftmost column */
    float right_cov = x1f - (float)px1;         /* coverage of rightmost column */
    float top_cov   = (float)(py0 + 1) - y0f;   /* coverage of top row */
    float bot_cov   = y1f - (float)py1;          /* coverage of bottom row */
    if (left_cov > 1.0f) left_cov = 1.0f;
    if (right_cov > 1.0f) right_cov = 1.0f;
    if (top_cov > 1.0f) top_cov = 1.0f;
    if (bot_cov > 1.0f) bot_cov = 1.0f;

    /* Interior column range (fully covered horizontally) */
    int ix0 = px0 + (left_cov < 0.999f ? 1 : 0);
    int ix1 = px1 - (right_cov < 0.999f ? 1 : 0);

    for (int row = py0; row <= py1; row++) {
        if (!in_band(row)) continue;

        /* Vertical coverage for this row */
        float ycov = 1.0f;
        if (py0 == py1) {
            ycov = y1f - y0f;
        } else if (row == py0) {
            ycov = top_cov;
        } else if (row == py1) {
            ycov = bot_cov;
        }
        if (ycov <= 0.0f) continue;

        bool is_edge_row = (row == py0 && top_cov < 0.999f) ||
                           (row == py1 && bot_cov < 0.999f);

        if (use_gradient) {
            for (int col = px0; col <= px1; col++) {
                float xcov = 1.0f;
                if (px0 == px1) { xcov = x1f - x0f; }
                else if (col == px0) { xcov = left_cov; }
                else if (col == px1) { xcov = right_cov; }
                float coverage = xcov * ycov;
                uint8_t gr, gg, gb, ga;
                resolve_fill_color((float)col + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                uint8_t aa = (uint8_t)(ga * coverage + 0.5f);
                if (aa > 0) put_pixel(col, row, gr, gg, gb, aa);
            }
        } else {
            /* Left edge pixel (AA) */
            if (left_cov < 0.999f && px0 <= px1) {
                float coverage = left_cov * ycov;
                uint8_t aa = (uint8_t)(fa * coverage + 0.5f);
                if (aa > 0) put_pixel(px0, row, fr, fg, fb, aa);
            }

            /* Interior pixels — fast path with fill_hline */
            if (ix0 <= ix1) {
                if (is_edge_row) {
                    /* Edge row: modulate alpha by vertical coverage */
                    uint8_t aa = (uint8_t)(fa * ycov + 0.5f);
                    fill_hline(ix0, ix1, row, fr, fg, fb, aa);
                } else {
                    fill_hline(ix0, ix1, row, fr, fg, fb, fa);
                }
            }

            /* Right edge pixel (AA) */
            if (right_cov < 0.999f && px1 > px0) {
                float coverage = right_cov * ycov;
                uint8_t aa = (uint8_t)(fa * coverage + 0.5f);
                if (aa > 0) put_pixel(px1, row, fr, fg, fb, aa);
            }
        }
    }
}

void ESP32Canvas::stroke_rect(float x, float y, float w, float h) {
    /* Stroke rectangle as 4 filled rects (AA handled by fill_rect) */
    float sw = _state.stroke_width;
    float half = sw / 2.0f;

    uint8_t sr = _state.stroke_r, sg = _state.stroke_g;
    uint8_t sb = _state.stroke_b, sa = _state.stroke_a;

    /* Temporarily set fill to stroke color */
    uint8_t save_fr = _state.fill_r, save_fg = _state.fill_g;
    uint8_t save_fb = _state.fill_b, save_fa = _state.fill_a;
    GradientType save_grad = _state.grad_type;
    _state.fill_r = sr; _state.fill_g = sg;
    _state.fill_b = sb; _state.fill_a = sa;
    _state.grad_type = GradientType::None;

    /* Top edge */
    fill_rect(x - half, y - half, w + sw, sw);
    /* Bottom edge */
    fill_rect(x - half, y + h - half, w + sw, sw);
    /* Left edge */
    fill_rect(x - half, y + half, sw, h - sw);
    /* Right edge */
    fill_rect(x + w - half, y + half, sw, h - sw);

    /* Restore fill state */
    _state.fill_r = save_fr; _state.fill_g = save_fg;
    _state.fill_b = save_fb; _state.fill_a = save_fa;
    _state.grad_type = save_grad;
}

void ESP32Canvas::fill_round_rect(float x, float y, float w, float h, float radius) {
    int ix = (int)x, iy = (int)y;
    int iw = (int)(x + w) - ix;
    int ih = (int)(y + h) - iy;
    int ir = (int)(radius + 0.5f);
    if (ir > iw / 2) ir = iw / 2;
    if (ir > ih / 2) ir = ih / 2;

    /* Early band rejection */
    if (iy + ih - 1 < _row_lo || iy > _row_hi) return;

    bool use_gradient = (_state.grad_type != GradientType::None);

    uint8_t fr = _state.fill_r, fg = _state.fill_g;
    uint8_t fb = _state.fill_b, fa = _state.fill_a;

    for (int row = iy; row < iy + ih; row++) {
        int rel_y = row - iy;

        /* Apply corner rounding with fractional coverage AA */
        if (rel_y < ir) {
            /* Top corners */
            int dy = ir - rel_y - 1;
            float dx_exact = ir - sqrtf((float)(ir * ir - dy * dy));
            int inset_full = (int)dx_exact;
            float frac = dx_exact - inset_full;
            uint8_t edge_alpha = (uint8_t)((1.0f - frac) * fa + 0.5f);

            int left_edge  = ix + inset_full;
            int right_edge = ix + iw - 1 - inset_full;
            int inner_x0   = left_edge + 1;
            int inner_x1   = right_edge - 1;

            if (left_edge == right_edge) {
                /* Single pixel wide — use edge alpha */
                if (use_gradient) {
                    uint8_t gr, gg, gb, ga;
                    resolve_fill_color((float)left_edge + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                    uint8_t aa = (uint8_t)((1.0f - frac) * ga + 0.5f);
                    if (aa > 0) put_pixel(left_edge, row, gr, gg, gb, aa);
                } else {
                    if (edge_alpha > 0) put_pixel(left_edge, row, fr, fg, fb, edge_alpha);
                }
            } else {
                /* Left edge pixel (partial coverage) */
                if (edge_alpha > 0) {
                    if (use_gradient) {
                        uint8_t gr, gg, gb, ga;
                        resolve_fill_color((float)left_edge + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                        uint8_t aa = (uint8_t)((1.0f - frac) * ga + 0.5f);
                        if (aa > 0) put_pixel(left_edge, row, gr, gg, gb, aa);
                    } else {
                        put_pixel(left_edge, row, fr, fg, fb, edge_alpha);
                    }
                }
                /* Solid interior fill */
                if (inner_x0 <= inner_x1) {
                    if (use_gradient) {
                        fill_hline_gradient(inner_x0, inner_x1, row);
                    } else {
                        fill_hline(inner_x0, inner_x1, row, fr, fg, fb, fa);
                    }
                }
                /* Right edge pixel (partial coverage) */
                if (edge_alpha > 0) {
                    if (use_gradient) {
                        uint8_t gr, gg, gb, ga;
                        resolve_fill_color((float)right_edge + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                        uint8_t aa = (uint8_t)((1.0f - frac) * ga + 0.5f);
                        if (aa > 0) put_pixel(right_edge, row, gr, gg, gb, aa);
                    } else {
                        put_pixel(right_edge, row, fr, fg, fb, edge_alpha);
                    }
                }
            }
        } else if (rel_y >= ih - ir) {
            /* Bottom corners */
            int dy = rel_y - (ih - ir);
            float dx_exact = ir - sqrtf((float)(ir * ir - dy * dy));
            int inset_full = (int)dx_exact;
            float frac = dx_exact - inset_full;
            uint8_t edge_alpha = (uint8_t)((1.0f - frac) * fa + 0.5f);

            int left_edge  = ix + inset_full;
            int right_edge = ix + iw - 1 - inset_full;
            int inner_x0   = left_edge + 1;
            int inner_x1   = right_edge - 1;

            if (left_edge == right_edge) {
                /* Single pixel wide — use edge alpha */
                if (use_gradient) {
                    uint8_t gr, gg, gb, ga;
                    resolve_fill_color((float)left_edge + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                    uint8_t aa = (uint8_t)((1.0f - frac) * ga + 0.5f);
                    if (aa > 0) put_pixel(left_edge, row, gr, gg, gb, aa);
                } else {
                    if (edge_alpha > 0) put_pixel(left_edge, row, fr, fg, fb, edge_alpha);
                }
            } else {
                /* Left edge pixel (partial coverage) */
                if (edge_alpha > 0) {
                    if (use_gradient) {
                        uint8_t gr, gg, gb, ga;
                        resolve_fill_color((float)left_edge + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                        uint8_t aa = (uint8_t)((1.0f - frac) * ga + 0.5f);
                        if (aa > 0) put_pixel(left_edge, row, gr, gg, gb, aa);
                    } else {
                        put_pixel(left_edge, row, fr, fg, fb, edge_alpha);
                    }
                }
                /* Solid interior fill */
                if (inner_x0 <= inner_x1) {
                    if (use_gradient) {
                        fill_hline_gradient(inner_x0, inner_x1, row);
                    } else {
                        fill_hline(inner_x0, inner_x1, row, fr, fg, fb, fa);
                    }
                }
                /* Right edge pixel (partial coverage) */
                if (edge_alpha > 0) {
                    if (use_gradient) {
                        uint8_t gr, gg, gb, ga;
                        resolve_fill_color((float)right_edge + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                        uint8_t aa = (uint8_t)((1.0f - frac) * ga + 0.5f);
                        if (aa > 0) put_pixel(right_edge, row, gr, gg, gb, aa);
                    } else {
                        put_pixel(right_edge, row, fr, fg, fb, edge_alpha);
                    }
                }
            }
        } else {
            /* Straight sides — full width, no AA needed */
            if (use_gradient) {
                fill_hline_gradient(ix, ix + iw - 1, row);
            } else {
                fill_hline(ix, ix + iw - 1, row, fr, fg, fb, fa);
            }
        }
    }
}

void ESP32Canvas::stroke_round_rect(float x, float y, float w, float h, float radius) {
    float sw = _state.stroke_width;
    uint8_t sr = _state.stroke_r, sg = _state.stroke_g;
    uint8_t sb = _state.stroke_b, sa = _state.stroke_a;
    int disc_r = (int)(sw / 2.0f + 0.5f);
    if (disc_r < 0) disc_r = 0;

    float cr = radius;
    if (cr > w / 2.0f) cr = w / 2.0f;
    if (cr > h / 2.0f) cr = h / 2.0f;

    /* Corner arc centers */
    float tl_cx = x + cr,         tl_cy = y + cr;          /* top-left */
    float tr_cx = x + w - cr,     tr_cy = y + cr;          /* top-right */
    float br_cx = x + w - cr,     br_cy = y + h - cr;      /* bottom-right */
    float bl_cx = x + cr,         bl_cy = y + h - cr;      /* bottom-left */

    /* Draw the four corner arcs using the round-cap arc stroker.
     * Angles: TL = PI..3PI/2, TR = 3PI/2..2PI, BR = 0..PI/2, BL = PI/2..PI */
    float pi  = (float)M_PI;
    float pi2 = pi / 2.0f;

    stroke_arc(tl_cx, tl_cy, cr, pi,        pi + pi2);    /* top-left */
    stroke_arc(tr_cx, tr_cy, cr, pi + pi2,  2.0f * pi);   /* top-right */
    stroke_arc(br_cx, br_cy, cr, 0.0f,      pi2);         /* bottom-right */
    stroke_arc(bl_cx, bl_cy, cr, pi2,       pi);           /* bottom-left */

    /* Straight edges — use fill_rect strips for efficiency.
     * Each edge is a filled rectangle of thickness stroke_width centered
     * on the geometric edge. */
    float half_sw = sw / 2.0f;

    /* Top edge: from top-left arc end to top-right arc start */
    {
        float ex0 = tl_cx;
        float ex1 = tr_cx;
        float ey  = y;
        int ix0 = (int)(ex0 + 0.5f);
        int ix1 = (int)(ex1 + 0.5f);
        int iy0 = (int)(ey - half_sw + 0.5f);
        int iy1 = (int)(ey + half_sw + 0.5f);
        for (int row = iy0; row <= iy1; row++) {
            if (!in_band(row)) continue;
            fill_hline(ix0, ix1, row, sr, sg, sb, sa);
        }
    }

    /* Bottom edge: from bottom-left arc end to bottom-right arc start */
    {
        float ex0 = bl_cx;
        float ex1 = br_cx;
        float ey  = y + h;
        int ix0 = (int)(ex0 + 0.5f);
        int ix1 = (int)(ex1 + 0.5f);
        int iy0 = (int)(ey - half_sw + 0.5f);
        int iy1 = (int)(ey + half_sw + 0.5f);
        for (int row = iy0; row <= iy1; row++) {
            if (!in_band(row)) continue;
            fill_hline(ix0, ix1, row, sr, sg, sb, sa);
        }
    }

    /* Left edge: from top-left arc end to bottom-left arc start */
    {
        float ex  = x;
        float ey0 = tl_cy;
        float ey1 = bl_cy;
        int ix0 = (int)(ex - half_sw + 0.5f);
        int ix1 = (int)(ex + half_sw + 0.5f);
        int iy0 = (int)(ey0 + 0.5f);
        int iy1 = (int)(ey1 + 0.5f);
        for (int row = iy0; row <= iy1; row++) {
            if (!in_band(row)) continue;
            fill_hline(ix0, ix1, row, sr, sg, sb, sa);
        }
    }

    /* Right edge: from top-right arc end to bottom-right arc start */
    {
        float ex  = x + w;
        float ey0 = tr_cy;
        float ey1 = br_cy;
        int ix0 = (int)(ex - half_sw + 0.5f);
        int ix1 = (int)(ex + half_sw + 0.5f);
        int iy0 = (int)(ey0 + 0.5f);
        int iy1 = (int)(ey1 + 0.5f);
        for (int row = iy0; row <= iy1; row++) {
            if (!in_band(row)) continue;
            fill_hline(ix0, ix1, row, sr, sg, sb, sa);
        }
    }
}

void ESP32Canvas::fill_circle(float cx, float cy, float r) {
    if (r <= 0.0f) return;

    /* Integer bounding box */
    int py0 = (int)floorf(cy - r);
    int py1 = (int)ceilf(cy + r);

    /* Early band rejection */
    if (py1 < _row_lo || py0 > _row_hi) return;

    bool use_gradient = (_state.grad_type != GradientType::None);
    uint8_t fr = _state.fill_r, fg = _state.fill_g;
    uint8_t fb = _state.fill_b, fa = _state.fill_a;
    float r2 = r * r;

    for (int row = py0; row <= py1; row++) {
        if (!in_band(row)) continue;

        /* Distance from pixel center to circle center (Y component) */
        float dy = (float)row + 0.5f - cy;
        float dy2 = dy * dy;
        if (dy2 >= r2) {
            /* Row center is outside circle — check if edge pixel */
            float dist = sqrtf(dy2) - r;
            if (dist >= 0.5f) continue; /* entirely outside */
            /* Thin sliver row — compute coverage for the narrow span */
            float ycov = 0.5f - dist;
            if (ycov <= 0.0f) continue;
            /* This row barely clips the circle — just draw center pixel */
            int col = (int)(cx + 0.5f);
            float col_dy = (float)col + 0.5f - cx;
            float d = sqrtf(dy2 + col_dy * col_dy) - r;
            float cov = 0.5f - d;
            if (cov > 0.0f) {
                if (cov > 1.0f) cov = 1.0f;
                if (use_gradient) {
                    uint8_t gr, gg, gb, ga;
                    resolve_fill_color((float)col + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                    uint8_t aa = (uint8_t)(ga * cov + 0.5f);
                    if (aa > 0) put_pixel(col, row, gr, gg, gb, aa);
                } else {
                    uint8_t aa = (uint8_t)(fa * cov + 0.5f);
                    if (aa > 0) put_pixel(col, row, fr, fg, fb, aa);
                }
            }
            continue;
        }

        /* Exact floating-point x-intercepts of circle edge at this scanline */
        float x_span = sqrtf(r2 - dy2);
        float x_left = cx - x_span;
        float x_right = cx + x_span;

        int px_left  = (int)floorf(x_left);
        int px_right = (int)floorf(x_right);

        /* Left AA edge pixel */
        {
            float dist = sqrtf(dy2 + ((float)px_left + 0.5f - cx) * ((float)px_left + 0.5f - cx)) - r;
            float cov = 0.5f - dist;
            if (cov < 0.0f) cov = 0.0f;
            if (cov > 1.0f) cov = 1.0f;
            if (cov > 0.0f) {
                if (use_gradient) {
                    uint8_t gr, gg, gb, ga;
                    resolve_fill_color((float)px_left + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                    uint8_t aa = (uint8_t)(ga * cov + 0.5f);
                    if (aa > 0) put_pixel(px_left, row, gr, gg, gb, aa);
                } else {
                    uint8_t aa = (uint8_t)(fa * cov + 0.5f);
                    if (aa > 0) put_pixel(px_left, row, fr, fg, fb, aa);
                }
            }
        }

        /* One more AA pixel outside left (pixel before px_left) */
        if (px_left > 0) {
            int px_outer = px_left - 1;
            float dist = sqrtf(dy2 + ((float)px_outer + 0.5f - cx) * ((float)px_outer + 0.5f - cx)) - r;
            float cov = 0.5f - dist;
            if (cov > 0.0f) {
                if (cov > 1.0f) cov = 1.0f;
                if (use_gradient) {
                    uint8_t gr, gg, gb, ga;
                    resolve_fill_color((float)px_outer + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                    uint8_t aa = (uint8_t)(ga * cov + 0.5f);
                    if (aa > 0) put_pixel(px_outer, row, gr, gg, gb, aa);
                } else {
                    uint8_t aa = (uint8_t)(fa * cov + 0.5f);
                    if (aa > 0) put_pixel(px_outer, row, fr, fg, fb, aa);
                }
            }
        }

        /* Interior pixels — fully opaque, use fast path */
        int interior_x0 = px_left + 1;
        int interior_x1 = px_right - 1;
        if (interior_x0 <= interior_x1) {
            if (use_gradient) {
                fill_hline_gradient(interior_x0, interior_x1, row);
            } else {
                fill_hline(interior_x0, interior_x1, row, fr, fg, fb, fa);
            }
        }

        /* Right AA edge pixel */
        if (px_right != px_left) {
            float dist = sqrtf(dy2 + ((float)px_right + 0.5f - cx) * ((float)px_right + 0.5f - cx)) - r;
            float cov = 0.5f - dist;
            if (cov < 0.0f) cov = 0.0f;
            if (cov > 1.0f) cov = 1.0f;
            if (cov > 0.0f) {
                if (use_gradient) {
                    uint8_t gr, gg, gb, ga;
                    resolve_fill_color((float)px_right + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                    uint8_t aa = (uint8_t)(ga * cov + 0.5f);
                    if (aa > 0) put_pixel(px_right, row, gr, gg, gb, aa);
                } else {
                    uint8_t aa = (uint8_t)(fa * cov + 0.5f);
                    if (aa > 0) put_pixel(px_right, row, fr, fg, fb, aa);
                }
            }
        }

        /* One more AA pixel outside right */
        {
            int px_outer = px_right + 1;
            float dist = sqrtf(dy2 + ((float)px_outer + 0.5f - cx) * ((float)px_outer + 0.5f - cx)) - r;
            float cov = 0.5f - dist;
            if (cov > 0.0f) {
                if (cov > 1.0f) cov = 1.0f;
                if (use_gradient) {
                    uint8_t gr, gg, gb, ga;
                    resolve_fill_color((float)px_outer + 0.5f, (float)row + 0.5f, gr, gg, gb, ga);
                    uint8_t aa = (uint8_t)(ga * cov + 0.5f);
                    if (aa > 0) put_pixel(px_outer, row, gr, gg, gb, aa);
                } else {
                    uint8_t aa = (uint8_t)(fa * cov + 0.5f);
                    if (aa > 0) put_pixel(px_outer, row, fr, fg, fb, aa);
                }
            }
        }
    }
}

void ESP32Canvas::stroke_circle(float cx, float cy, float r) {
    /* Full-circle stroke via the uniform-thickness arc stroker */
    stroke_arc(cx, cy, r, 0.0f, 2.0f * (float)M_PI);
}

/* -------------------------------------------------------------------
 * fill_arc — filled pie sector ([CXC-R-DRAW-CONTRACT], M5)
 *
 * Per-pixel radius test with edge AA on the circular rim; the two
 * straight sector edges are hard-edged (documented AA delta class —
 * Skia AA's them).  Angle convention matches stroke_arc / Python:
 * radians, 0 = +X, positive CW in screen space (Y down).
 * ------------------------------------------------------------------- */

void ESP32Canvas::fill_arc(float cx, float cy, float r,
                           float start_angle, float end_angle) {
    if (r <= 0.0f) return;

    float sweep = end_angle - start_angle;
    if (sweep == 0.0f) return;
    if (sweep < 0.0f) { start_angle = end_angle; sweep = -sweep; }
    const float two_pi = 2.0f * (float)M_PI;
    bool full_circle = (sweep >= two_pi - 1e-4f);

    /* Normalize start into [0, 2pi) */
    float a0 = fmodf(start_angle, two_pi);
    if (a0 < 0) a0 += two_pi;

    int py0 = (int)floorf(cy - r) - 1;
    int py1 = (int)ceilf(cy + r) + 1;
    if (py1 < _row_lo || py0 > _row_hi) return;

    bool use_gradient = (_state.grad_type != GradientType::None);
    uint8_t fr = _state.fill_r, fg = _state.fill_g;
    uint8_t fb = _state.fill_b, fa = _state.fill_a;

    int px0 = (int)floorf(cx - r) - 1;
    int px1 = (int)ceilf(cx + r) + 1;

    for (int row = py0; row <= py1; row++) {
        if (!in_band(row)) continue;
        float dy = (float)row + 0.5f - cy;

        for (int col = px0; col <= px1; col++) {
            float dx = (float)col + 0.5f - cx;
            float dist = sqrtf(dx * dx + dy * dy);

            /* Rim AA coverage */
            float cov = r - dist + 0.5f;
            if (cov <= 0.0f) continue;
            if (cov > 1.0f) cov = 1.0f;

            if (!full_circle) {
                float ang = atan2f(dy, dx);
                float rel = ang - a0;
                rel = fmodf(rel, two_pi);
                if (rel < 0) rel += two_pi;
                if (rel > sweep) continue;
            }

            if (use_gradient) {
                uint8_t gr, gg, gb, ga;
                resolve_fill_color((float)col + 0.5f, (float)row + 0.5f,
                                   gr, gg, gb, ga);
                uint8_t aa = (uint8_t)(ga * cov + 0.5f);
                if (aa > 0) put_pixel(col, row, gr, gg, gb, aa);
            } else {
                uint8_t aa = (uint8_t)(fa * cov + 0.5f);
                if (aa > 0) put_pixel(col, row, fr, fg, fb, aa);
            }
        }
    }
}

/* -------------------------------------------------------------------
 * Paths ([CXC-R-DRAW-CONTRACT], M5)
 *
 * Flattening: Quad/Cubic subdivide into kCurveSteps segments.
 * fill_path: scanline even-odd fill across all subpaths (hard edges —
 * documented AA delta class).  draw_path: stroke each flattened
 * segment with draw_line (round caps overlap at joins).
 *
 * Static edge pool: single-threaded band renderer, no per-frame heap.
 * ------------------------------------------------------------------- */

static constexpr int kCurveSteps = 16;
static constexpr int kMaxPathEdges = 384;

struct PathEdge { float x0, y0, x1, y1; };
static PathEdge s_path_edges[kMaxPathEdges];

/* Flatten commands into the edge pool. Returns edge count (-1 = overflow). */
static int flatten_path(const PathCommand* cmds, int count, bool close_all) {
    int n = 0;
    float cur_x = 0, cur_y = 0;
    float sub_x = 0, sub_y = 0;
    bool have_cur = false;

    auto emit = [&](float x0, float y0, float x1, float y1) -> bool {
        if (x0 == x1 && y0 == y1) return true;
        if (n >= kMaxPathEdges) return false;
        s_path_edges[n++] = PathEdge{x0, y0, x1, y1};
        return true;
    };

    for (int i = 0; i < count; i++) {
        const PathCommand& c = cmds[i];
        switch (c.op) {
            case PathCommand::Op::Move:
                /* implicit close of previous subpath when filling */
                if (close_all && have_cur &&
                    (cur_x != sub_x || cur_y != sub_y)) {
                    if (!emit(cur_x, cur_y, sub_x, sub_y)) return -1;
                }
                cur_x = sub_x = c.x;
                cur_y = sub_y = c.y;
                have_cur = true;
                break;
            case PathCommand::Op::Line:
                if (!have_cur) { cur_x = sub_x = c.x; cur_y = sub_y = c.y; have_cur = true; break; }
                if (!emit(cur_x, cur_y, c.x, c.y)) return -1;
                cur_x = c.x; cur_y = c.y;
                break;
            case PathCommand::Op::Quad: {
                if (!have_cur) { cur_x = sub_x = c.x; cur_y = sub_y = c.y; have_cur = true; break; }
                float px = cur_x, py = cur_y;
                for (int s = 1; s <= kCurveSteps; s++) {
                    float t = (float)s / kCurveSteps;
                    float mt = 1.0f - t;
                    float bx = mt * mt * cur_x + 2 * mt * t * c.cx1 + t * t * c.x;
                    float by = mt * mt * cur_y + 2 * mt * t * c.cy1 + t * t * c.y;
                    if (!emit(px, py, bx, by)) return -1;
                    px = bx; py = by;
                }
                cur_x = c.x; cur_y = c.y;
                break;
            }
            case PathCommand::Op::Cubic: {
                if (!have_cur) { cur_x = sub_x = c.x; cur_y = sub_y = c.y; have_cur = true; break; }
                float px = cur_x, py = cur_y;
                for (int s = 1; s <= kCurveSteps; s++) {
                    float t = (float)s / kCurveSteps;
                    float mt = 1.0f - t;
                    float bx = mt * mt * mt * cur_x + 3 * mt * mt * t * c.cx1 +
                               3 * mt * t * t * c.cx2 + t * t * t * c.x;
                    float by = mt * mt * mt * cur_y + 3 * mt * mt * t * c.cy1 +
                               3 * mt * t * t * c.cy2 + t * t * t * c.y;
                    if (!emit(px, py, bx, by)) return -1;
                    px = bx; py = by;
                }
                cur_x = c.x; cur_y = c.y;
                break;
            }
            case PathCommand::Op::Close:
                if (have_cur && (cur_x != sub_x || cur_y != sub_y)) {
                    if (!emit(cur_x, cur_y, sub_x, sub_y)) return -1;
                }
                cur_x = sub_x; cur_y = sub_y;
                break;
        }
    }
    /* Implicit final close when filling */
    if (close_all && have_cur && (cur_x != sub_x || cur_y != sub_y)) {
        if (!emit(cur_x, cur_y, sub_x, sub_y)) return -1;
    }
    return n;
}

void ESP32Canvas::draw_path(const PathCommand* cmds, int count) {
    int n = flatten_path(cmds, count, false);
    if (n < 0) {
        ESP_LOGW(TAG, "draw_path: edge pool overflow (>%d), path truncated",
                 kMaxPathEdges);
        n = kMaxPathEdges;
    }
    for (int i = 0; i < n; i++) {
        draw_line(s_path_edges[i].x0, s_path_edges[i].y0,
                  s_path_edges[i].x1, s_path_edges[i].y1);
    }
}

void ESP32Canvas::fill_path(const PathCommand* cmds, int count) {
    int n = flatten_path(cmds, count, true);
    if (n < 0) {
        ESP_LOGW(TAG, "fill_path: edge pool overflow (>%d), path dropped",
                 kMaxPathEdges);
        return;
    }
    if (n == 0) return;

    /* Bounding rows */
    float min_y = s_path_edges[0].y0, max_y = s_path_edges[0].y0;
    for (int i = 0; i < n; i++) {
        min_y = std::min({min_y, s_path_edges[i].y0, s_path_edges[i].y1});
        max_y = std::max({max_y, s_path_edges[i].y0, s_path_edges[i].y1});
    }
    int ry0 = (int)floorf(min_y);
    int ry1 = (int)ceilf(max_y);
    if (ry1 < _row_lo || ry0 > _row_hi) return;

    bool use_gradient = (_state.grad_type != GradientType::None);
    uint8_t fr = _state.fill_r, fg = _state.fill_g;
    uint8_t fb = _state.fill_b, fa = _state.fill_a;

    static constexpr int kMaxCrossings = 32;
    float xs[kMaxCrossings];

    for (int row = ry0; row <= ry1; row++) {
        if (!in_band(row)) continue;
        float sy = (float)row + 0.5f;

        int nx = 0;
        for (int i = 0; i < n && nx < kMaxCrossings; i++) {
            float y0 = s_path_edges[i].y0, y1 = s_path_edges[i].y1;
            if ((sy >= y0 && sy < y1) || (sy >= y1 && sy < y0)) {
                float t = (sy - y0) / (y1 - y0);
                xs[nx++] = s_path_edges[i].x0 +
                           t * (s_path_edges[i].x1 - s_path_edges[i].x0);
            }
        }
        /* insertion sort (nx is small) */
        for (int i = 1; i < nx; i++) {
            float v = xs[i];
            int j = i - 1;
            while (j >= 0 && xs[j] > v) { xs[j + 1] = xs[j]; j--; }
            xs[j + 1] = v;
        }
        /* even-odd span fill */
        for (int i = 0; i + 1 < nx; i += 2) {
            int x0 = (int)ceilf(xs[i] - 0.5f);
            int x1 = (int)floorf(xs[i + 1] - 0.5f);
            if (x0 > x1) continue;
            if (use_gradient) {
                fill_hline_gradient(x0, x1, row);
            } else {
                fill_hline(x0, x1, row, fr, fg, fb, fa);
            }
        }
    }
}

/* -------------------------------------------------------------------
 * Line drawing (Bresenham)
 * ------------------------------------------------------------------- */

void ESP32Canvas::draw_line(float x1, float y1, float x2, float y2) {
    uint8_t sr = _state.stroke_r, sg = _state.stroke_g;
    uint8_t sb = _state.stroke_b, sa = _state.stroke_a;
    float sw = _state.stroke_width;

    float dx = x2 - x1;
    float dy = y2 - y1;
    float line_len = sqrtf(dx * dx + dy * dy);

    if (line_len < 0.001f) {
        /* Degenerate: single point */
        put_pixel((int)(x1 + 0.5f), (int)(y1 + 0.5f), sr, sg, sb, sa);
        return;
    }

    /* Perpendicular unit normal */
    float nx = -dy / line_len;
    float ny =  dx / line_len;
    float half_w = sw / 2.0f;

    /* For thin lines (stroke_width <= 1), use Xiaolin Wu's algorithm */
    if (sw <= 1.5f) {
        bool steep = fabsf(dy) > fabsf(dx);
        float fx1 = x1, fy1 = y1, fx2 = x2, fy2 = y2;

        if (steep) {
            /* Swap x and y */
            float tmp;
            tmp = fx1; fx1 = fy1; fy1 = tmp;
            tmp = fx2; fx2 = fy2; fy2 = tmp;
        }
        if (fx1 > fx2) {
            float tmp;
            tmp = fx1; fx1 = fx2; fx2 = tmp;
            tmp = fy1; fy1 = fy2; fy2 = tmp;
        }

        float grad = (fx2 - fx1 > 0.001f) ? (fy2 - fy1) / (fx2 - fx1) : 0.0f;

        /* First endpoint */
        int xpxl1 = (int)(fx1 + 0.5f);
        float yend1 = fy1 + grad * ((float)xpxl1 - fx1);
        int ypxl1 = (int)floorf(yend1);
        float frac1 = yend1 - (float)ypxl1;

        if (steep) {
            put_pixel(ypxl1,     xpxl1, sr, sg, sb, (uint8_t)(sa * (1.0f - frac1) + 0.5f));
            put_pixel(ypxl1 + 1, xpxl1, sr, sg, sb, (uint8_t)(sa * frac1 + 0.5f));
        } else {
            put_pixel(xpxl1, ypxl1,     sr, sg, sb, (uint8_t)(sa * (1.0f - frac1) + 0.5f));
            put_pixel(xpxl1, ypxl1 + 1, sr, sg, sb, (uint8_t)(sa * frac1 + 0.5f));
        }

        float intery = yend1 + grad;

        /* Second endpoint */
        int xpxl2 = (int)(fx2 + 0.5f);
        float yend2 = fy2 + grad * ((float)xpxl2 - fx2);
        int ypxl2 = (int)floorf(yend2);
        float frac2 = yend2 - (float)ypxl2;

        if (steep) {
            put_pixel(ypxl2,     xpxl2, sr, sg, sb, (uint8_t)(sa * (1.0f - frac2) + 0.5f));
            put_pixel(ypxl2 + 1, xpxl2, sr, sg, sb, (uint8_t)(sa * frac2 + 0.5f));
        } else {
            put_pixel(xpxl2, ypxl2,     sr, sg, sb, (uint8_t)(sa * (1.0f - frac2) + 0.5f));
            put_pixel(xpxl2, ypxl2 + 1, sr, sg, sb, (uint8_t)(sa * frac2 + 0.5f));
        }

        /* Main loop */
        for (int xi = xpxl1 + 1; xi < xpxl2; xi++) {
            int iy = (int)floorf(intery);
            float frac = intery - (float)iy;
            if (steep) {
                put_pixel(iy,     xi, sr, sg, sb, (uint8_t)(sa * (1.0f - frac) + 0.5f));
                put_pixel(iy + 1, xi, sr, sg, sb, (uint8_t)(sa * frac + 0.5f));
            } else {
                put_pixel(xi, iy,     sr, sg, sb, (uint8_t)(sa * (1.0f - frac) + 0.5f));
                put_pixel(xi, iy + 1, sr, sg, sb, (uint8_t)(sa * frac + 0.5f));
            }
            intery += grad;
        }
    } else {
        /* Thick line: rasterize as a filled parallelogram with AA edges.
         * For each scanline, compute perpendicular distance from pixel to line
         * center and map to coverage. */
        int min_y = (int)floorf(std::min({y1, y2, y1 + nx * half_w, y1 - nx * half_w,
                                          y2 + nx * half_w, y2 - nx * half_w})) - 1;
        int max_y = (int)ceilf(std::max({y1, y2, y1 + nx * half_w, y1 - nx * half_w,
                                         y2 + nx * half_w, y2 - nx * half_w})) + 1;
        int min_x = (int)floorf(std::min({x1, x2, x1 + ny * half_w, x1 - ny * half_w,
                                          x2 + ny * half_w, x2 - ny * half_w})) - 1;
        int max_x = (int)ceilf(std::max({x1, x2, x1 + ny * half_w, x1 - ny * half_w,
                                         x2 + ny * half_w, x2 - ny * half_w})) + 1;

        /* Direction along line */
        float tx = dx / line_len;
        float ty = dy / line_len;

        for (int row = min_y; row <= max_y; row++) {
            if (!in_band(row)) continue;
            for (int col = min_x; col <= max_x; col++) {
                float px = (float)col + 0.5f - x1;
                float py = (float)row + 0.5f - y1;

                /* Distance along line direction */
                float along = px * tx + py * ty;
                /* Distance perpendicular to line */
                float perp = fabsf(px * nx + py * ny);

                /* Coverage from perpendicular distance */
                float perp_cov = half_w + 0.5f - perp;
                if (perp_cov <= 0.0f) continue;
                if (perp_cov > 1.0f) perp_cov = 1.0f;

                /* Coverage from endpoints (cap distance) */
                float cap_cov = 1.0f;
                if (along < 0.0f) {
                    cap_cov = along + 0.5f;
                } else if (along > line_len) {
                    cap_cov = 0.5f - (along - line_len);
                }
                if (cap_cov <= 0.0f) continue;
                if (cap_cov > 1.0f) cap_cov = 1.0f;

                float cov = perp_cov * cap_cov;
                uint8_t aa = (uint8_t)(sa * cov + 0.5f);
                if (aa > 0) put_pixel(col, row, sr, sg, sb, aa);
            }
        }
    }
}

/* -------------------------------------------------------------------
 * Stamp stroke disc — filled circle at a point, using explicit color.
 * This is the core primitive for round-cap curve stroking.
 * ------------------------------------------------------------------- */

void ESP32Canvas::stamp_stroke_disc(int icx, int icy, int ir,
                                    uint8_t cr, uint8_t cg, uint8_t cb, uint8_t ca) {
    if (ir <= 0) {
        /* Degenerate: single pixel */
        put_pixel(icx, icy, cr, cg, cb, ca);
        return;
    }

    /* Early band rejection */
    if (icy + ir + 1 < _row_lo || icy - ir - 1 > _row_hi) return;

    float rf = (float)ir;
    float r2 = rf * rf;

    for (int dy = -ir - 1; dy <= ir + 1; dy++) {
        int y = icy + dy;
        if (!in_band(y)) continue;

        float fy = (float)dy;
        float fy2 = fy * fy;

        if (fy2 >= r2) {
            /* Outside circle by Y alone — check for AA edge pixels */
            float dist_y = sqrtf(fy2) - rf;
            if (dist_y >= 0.5f) continue;
            /* Thin sliver: just draw the center pixel with AA */
            float dist = sqrtf(fy2) - rf;
            float cov = 0.5f - dist;
            if (cov > 0.0f && cov <= 1.0f) {
                uint8_t aa = (uint8_t)(ca * cov + 0.5f);
                if (aa > 0) put_pixel(icx, y, cr, cg, cb, aa);
            }
            continue;
        }

        /* Exact x-intercepts */
        float x_span = sqrtf(r2 - fy2);
        int px_left  = (int)floorf((float)icx - x_span);
        int px_right = (int)floorf((float)icx + x_span);

        /* Left outer AA pixel */
        {
            int px = px_left - 1;
            float dx_f = (float)(px - icx) + 0.5f;
            float dist = sqrtf(fy2 + dx_f * dx_f) - rf;
            float cov = 0.5f - dist;
            if (cov > 0.0f) {
                if (cov > 1.0f) cov = 1.0f;
                uint8_t aa = (uint8_t)(ca * cov + 0.5f);
                if (aa > 0) put_pixel(px, y, cr, cg, cb, aa);
            }
        }

        /* Left edge AA pixel */
        {
            float dx_f = (float)(px_left - icx) + 0.5f;
            float dist = sqrtf(fy2 + dx_f * dx_f) - rf;
            float cov = 0.5f - dist;
            if (cov < 0.0f) cov = 0.0f;
            if (cov > 1.0f) cov = 1.0f;
            if (cov > 0.0f && cov < 0.999f) {
                uint8_t aa = (uint8_t)(ca * cov + 0.5f);
                if (aa > 0) put_pixel(px_left, y, cr, cg, cb, aa);
            } else if (cov >= 0.999f) {
                put_pixel(px_left, y, cr, cg, cb, ca);
            }
        }

        /* Interior pixels — fully opaque */
        int ix0 = px_left + 1;
        int ix1 = px_right - 1;
        if (ix0 <= ix1) {
            fill_hline(ix0, ix1, y, cr, cg, cb, ca);
        }

        /* Right edge AA pixel */
        if (px_right != px_left) {
            float dx_f = (float)(px_right - icx) + 0.5f;
            float dist = sqrtf(fy2 + dx_f * dx_f) - rf;
            float cov = 0.5f - dist;
            if (cov < 0.0f) cov = 0.0f;
            if (cov > 1.0f) cov = 1.0f;
            if (cov > 0.0f && cov < 0.999f) {
                uint8_t aa = (uint8_t)(ca * cov + 0.5f);
                if (aa > 0) put_pixel(px_right, y, cr, cg, cb, aa);
            } else if (cov >= 0.999f) {
                put_pixel(px_right, y, cr, cg, cb, ca);
            }
        }

        /* Right outer AA pixel */
        {
            int px = px_right + 1;
            float dx_f = (float)(px - icx) + 0.5f;
            float dist = sqrtf(fy2 + dx_f * dx_f) - rf;
            float cov = 0.5f - dist;
            if (cov > 0.0f) {
                if (cov > 1.0f) cov = 1.0f;
                uint8_t aa = (uint8_t)(ca * cov + 0.5f);
                if (aa > 0) put_pixel(px, y, cr, cg, cb, aa);
            }
        }
    }
}

/* -------------------------------------------------------------------
 * Arc stroke — round-cap stroking via stamped discs
 *
 * Instead of connecting arc points with Bresenham line segments
 * (which produce variable thickness at different angles), we stamp
 * a filled circle of radius stroke_width/2 at each point along the
 * arc. This is how Skia, Cairo, and all serious 2D renderers handle
 * path stroking.
 * ------------------------------------------------------------------- */

void ESP32Canvas::stroke_arc(float cx, float cy, float r,
                             float start_angle, float end_angle) {
    uint8_t sr = _state.stroke_r, sg = _state.stroke_g;
    uint8_t sb = _state.stroke_b, sa = _state.stroke_a;
    float sw = _state.stroke_width;
    int disc_r = (int)(sw / 2.0f + 0.5f);
    if (disc_r < 0) disc_r = 0;

    /* Early band rejection: arc center +/- radius +/- disc radius */
    int outer = (int)(r + 0.5f) + disc_r;
    int icy = (int)(cy + 0.5f);
    if (icy + outer < _row_lo || icy - outer > _row_hi) return;

    /* Angular step: ~1 pixel spacing between stamps along the arc.
     * step = 1 / R radians gives ~1px arc-length per step.
     * Clamp to at most 0.5 degrees for very large radii. */
    float abs_sweep = fabsf(end_angle - start_angle);
    float ang_step;
    if (r > 1.0f) {
        ang_step = 1.0f / r;                          /* ~1px spacing */
        float min_step = 0.5f * (float)M_PI / 180.0f; /* 0.5 degrees */
        if (ang_step < min_step) ang_step = min_step;
    } else {
        ang_step = 0.1f; /* Very small radius — fine step */
    }

    int steps = (int)(abs_sweep / ang_step) + 1;
    if (steps < 1) steps = 1;

    float direction = (end_angle >= start_angle) ? 1.0f : -1.0f;

    for (int i = 0; i <= steps; i++) {
        float angle = start_angle + direction * ang_step * (float)i;
        /* Clamp to end_angle on the last step */
        if (direction > 0 && angle > end_angle) angle = end_angle;
        if (direction < 0 && angle < end_angle) angle = end_angle;

        int px = (int)(cx + cosf(angle) * r + 0.5f);
        int py = (int)(cy + sinf(angle) * r + 0.5f);
        stamp_stroke_disc(px, py, disc_r, sr, sg, sb, sa);
    }
}

/* -------------------------------------------------------------------
 * Style state
 * ------------------------------------------------------------------- */

void ESP32Canvas::set_fill_color(uint8_t r, uint8_t g, uint8_t b, uint8_t a) {
    _state.fill_r = r; _state.fill_g = g; _state.fill_b = b; _state.fill_a = a;
    _state.grad_type = GradientType::None;
}

void ESP32Canvas::set_stroke_color(uint8_t r, uint8_t g, uint8_t b, uint8_t a) {
    _state.stroke_r = r; _state.stroke_g = g; _state.stroke_b = b; _state.stroke_a = a;
}

void ESP32Canvas::set_stroke_width(float w) {
    _state.stroke_width = w;
}

void ESP32Canvas::set_linear_gradient(float x1, float y1, float x2, float y2,
                                       const GradientStop* stops, int count) {
    _state.grad_type = GradientType::Linear;
    _state.grad_x1 = x1; _state.grad_y1 = y1;
    _state.grad_x2 = x2; _state.grad_y2 = y2;
    _state.grad_stop_count = (count > kMaxGradientStops) ? kMaxGradientStops : count;
    for (int i = 0; i < _state.grad_stop_count; i++) {
        _state.grad_stops[i] = stops[i];
    }
}

void ESP32Canvas::set_radial_gradient(float cx, float cy, float radius,
                                       const GradientStop* stops, int count) {
    _state.grad_type = GradientType::Radial;
    _state.grad_cx = cx; _state.grad_cy = cy; _state.grad_r = radius;
    _state.grad_stop_count = (count > kMaxGradientStops) ? kMaxGradientStops : count;
    for (int i = 0; i < _state.grad_stop_count; i++) {
        _state.grad_stops[i] = stops[i];
    }
}

void ESP32Canvas::set_shadow(float offset_x, float offset_y, float blur,
                              uint8_t r, uint8_t g, uint8_t b, uint8_t a) {
    _state.has_shadow = (a > 0 && (blur > 0 || offset_x != 0 || offset_y != 0));
    _state.shadow_ox = offset_x;
    _state.shadow_oy = offset_y;
    _state.shadow_blur = blur;
    _state.shadow_r = r; _state.shadow_g = g; _state.shadow_b = b; _state.shadow_a = a;
}

void ESP32Canvas::clear_shadow() {
    _state.has_shadow = false;
}

void ESP32Canvas::set_opacity(float a) {
    /* Real since M5: global alpha multiplier applied to every pixel
     * write (put_pixel), saved/restored with the graphics state. */
    if (a < 0.0f) a = 0.0f;
    if (a > 1.0f) a = 1.0f;
    _state.opacity = a;
}

/* -------------------------------------------------------------------
 * Save / Restore
 * ------------------------------------------------------------------- */

void ESP32Canvas::save() {
    if (_state_depth < kMaxStateDepth) {
        _state_stack[_state_depth] = _state;
        _state_depth++;
    }
}

void ESP32Canvas::restore() {
    if (_state_depth > 0) {
        _state_depth--;
        _state = _state_stack[_state_depth];
    }
}

/* Transform ops — contract stubs ([CXC-R-DRAW] 2026-07-06, the
 * [SPEC:CXC-BIND] bindable-transform pass).  A raster transform inside
 * the 16-scanline band renderer is M5+ work (rotate requires either a
 * full-frame scratch surface or per-band inverse-mapping); until then
 * these are documented no-ops and transform-bound widgets draw
 * untransformed on this tier.  Kept virtual-complete so the C++
 * contract stays in lockstep with the Python ABC. */

void ESP32Canvas::translate(float /*dx*/, float /*dy*/) {}
void ESP32Canvas::rotate(float /*angle*/) {}
void ESP32Canvas::scale(float /*sx*/, float /*sy*/) {}

void ESP32Canvas::clip_rect(float x, float y, float w, float h) {
    if (_state.has_clip) {
        float cx1 = std::max(x, _state.clip_x);
        float cy1 = std::max(y, _state.clip_y);
        float cx2 = std::min(x + w, _state.clip_x + _state.clip_w);
        float cy2 = std::min(y + h, _state.clip_y + _state.clip_h);
        _state.clip_x = cx1;
        _state.clip_y = cy1;
        _state.clip_w = (cx2 > cx1) ? cx2 - cx1 : 0;
        _state.clip_h = (cy2 > cy1) ? cy2 - cy1 : 0;
    } else {
        _state.clip_x = x;
        _state.clip_y = y;
        _state.clip_w = w;
        _state.clip_h = h;
        _state.has_clip = true;
    }
    _state.clip_radius = 0.0f;   /* a plain clip is rectangular */
}

void ESP32Canvas::clip_round_rect(float x, float y, float w, float h,
                                  float radius) {
    /* Axis-aligned bounds first (intersects any existing clip); then the
     * corner radius, clamped to half the smaller extent.  Nested rounded
     * clips are not composited (the arc applies to THIS rect) — the only
     * use-site (the gauge bar fill) clips a fresh save()d state. */
    clip_rect(x, y, w, h);
    float maxr = std::min(_state.clip_w, _state.clip_h) * 0.5f;
    if (radius < 0.0f) radius = 0.0f;
    if (radius > maxr) radius = maxr;
    _state.clip_radius = radius;
}

/* -------------------------------------------------------------------
 * Text rendering
 *
 * If a generated font atlas is available (font_atlas.h), use it for
 * antialiased proportional text. Otherwise fall back to the 8x16 bitmap.
 * ------------------------------------------------------------------- */

/* Case-insensitive family match: "commp" / "common pixel" -> the COMMP
 * pixel family; anything else -> the default sans-serif family.  Local
 * (not the atlas header's helper) so set_font works in the no-atlas
 * fallback build too. */
static bool family_is_commp(const char* family) {
    if (!family) return false;
    auto lc = [](char c) -> char {
        return (c >= 'A' && c <= 'Z') ? (char)(c - 'A' + 'a') : c; };
    auto ieq = [&](const char* s, const char* t) -> bool {
        while (*s && *t) { if (lc(*s) != lc(*t)) return false; s++; t++; }
        return *s == *t; };
    return ieq(family, "commp") || ieq(family, "common pixel");
}

void ESP32Canvas::set_font(const char* family, float size, const char* weight) {
    _state.font_size = size;
    _state.font_bold = (weight && weight[0] == 'b');
    _state.font_commp = family_is_commp(family);
}

#if HAS_FONT_ATLAS

TextMetrics ESP32Canvas::measure_text(const char* text) {
    /* Find the best matching atlas size (bold or regular) */
    int target = (int)(_state.font_size + 0.5f);
    const FontAtlas* atlas = font_atlas_find_styled(_state.font_commp, _state.font_bold, target);
    if (!atlas) {
        /* Fallback to bitmap measurement */
        int len = 0; while (text[len]) len++;
        float scale = _state.font_size / (float)kFontH;
        float w = len * kFontW * scale;
        float h = kFontH * scale;
        return TextMetrics{w, h, h * 0.8f, h * 0.2f};
    }

    float scale = _state.font_size / (float)atlas->size;
    float width = 0;
    for (int i = 0; text[i]; i++) {
        int ch = (unsigned char)text[i];
        const FontGlyph* g = font_atlas_glyph(atlas, ch);
        if (g) {
            width += g->advance * scale;
        } else {
            width += atlas->size * 0.5f * scale; /* fallback width */
        }
    }
    float height = atlas->line_height * scale;
    float ascent = atlas->ascent * scale;
    float descent = atlas->descent * scale;
    return TextMetrics{width, height, ascent, descent};
}

void ESP32Canvas::draw_text(const char* text, float x, float y, const char* align) {
    if (!text || !text[0]) return;

    int target = (int)(_state.font_size + 0.5f);
    const FontAtlas* atlas = font_atlas_find_styled(_state.font_commp, _state.font_bold, target);

    if (!atlas) {
        /* Fall back to bitmap font — see below */
        goto bitmap_fallback;
    }

    {
        float scale = _state.font_size / (float)atlas->size;
        TextMetrics m = measure_text(text);

        float draw_x = x;
        if (align[0] == 'c') draw_x = x - m.width / 2.0f;
        else if (align[0] == 'r') draw_x = x - m.width;

        float draw_y = y - m.ascent;

        uint8_t fr = _state.fill_r, fg = _state.fill_g, fb = _state.fill_b, fa = _state.fill_a;

        for (int ci = 0; text[ci]; ci++) {
            int ch = (unsigned char)text[ci];
            const FontGlyph* glyph = font_atlas_glyph(atlas, ch);
            if (!glyph) {
                draw_x += atlas->size * 0.5f * scale;
                continue;
            }
            if (!glyph->bitmap) {
                /* Bitmap-less glyph (space): honor its REAL advance —
                 * the old 0.5*size fallback double-spaced text and
                 * diverged from measure_text (found by the M5 config
                 * crosscheck). */
                draw_x += glyph->advance * scale;
                continue;
            }

            int glyph_w = glyph->width;
            int glyph_h = glyph->height;
            float gx = draw_x + glyph->bearing_x * scale;
            float gy = draw_y + (atlas->ascent - glyph->bearing_y) * scale;

            /* Render glyph bitmap with scaling */
            int sw = (int)(glyph_w * scale + 0.5f);
            int sh = (int)(glyph_h * scale + 0.5f);
            int igx = (int)(gx + 0.5f);
            int igy = (int)(gy + 0.5f);

            for (int py = 0; py < sh; py++) {
                int src_row = py * glyph_h / sh;
                int screen_y = igy + py;
                if (!in_band(screen_y)) continue;

                for (int px = 0; px < sw; px++) {
                    int src_col = px * glyph_w / sw;
                    uint8_t alpha = glyph->bitmap[src_row * glyph_w + src_col];
                    if (alpha == 0) continue;

                    /* Modulate glyph alpha with fill alpha */
                    uint8_t final_a = (uint8_t)((alpha * fa + 127) / 255);
                    put_pixel(igx + px, screen_y, fr, fg, fb, final_a);
                }
            }

            draw_x += glyph->advance * scale;
        }
        return;
    }

bitmap_fallback:
    /* 8x16 bitmap font rendering */
    {
        float scale = _state.font_size / (float)kFontH;
        TextMetrics m = measure_text(text);

        float draw_x = x;
        if (align[0] == 'c') draw_x = x - m.width / 2.0f;
        else if (align[0] == 'r') draw_x = x - m.width;

        float draw_y = y - m.ascent;

        uint8_t r = _state.fill_r, g = _state.fill_g, b = _state.fill_b, a = _state.fill_a;

        for (int ci = 0; text[ci]; ci++) {
            int ch = (unsigned char)text[ci];
            if (ch < kFontFirstChar || ch > kFontLastChar) ch = '?';
            int idx = ch - kFontFirstChar;

            const uint8_t* glyph = font_8x16[idx];
            float gx = draw_x + ci * kFontW * scale;

            int sw = (int)(kFontW * scale + 0.5f);
            int sh = (int)(kFontH * scale + 0.5f);
            int igx = (int)(gx + 0.5f);
            int igy = (int)(draw_y + 0.5f);

            for (int py = 0; py < sh; py++) {
                int src_row = py * kFontH / sh;
                int screen_y = igy + py;
                if (!in_band(screen_y)) continue;

                uint8_t bits = glyph[src_row];
                if (bits == 0) continue;
                for (int px = 0; px < sw; px++) {
                    int src_col = px * kFontW / sw;
                    if (bits & (0x80 >> src_col)) {
                        put_pixel(igx + px, screen_y, r, g, b, a);
                    }
                }
            }
        }
    }
}

#else /* No font atlas — bitmap font only */

TextMetrics ESP32Canvas::measure_text(const char* text) {
    int len = 0;
    while (text[len]) len++;

    float scale = _state.font_size / (float)kFontH;
    float w = len * kFontW * scale;
    float h = kFontH * scale;
    return TextMetrics{w, h, h * 0.8f, h * 0.2f};
}

void ESP32Canvas::draw_text(const char* text, float x, float y, const char* align) {
    if (!text || !text[0]) return;

    float scale = _state.font_size / (float)kFontH;
    TextMetrics m = measure_text(text);

    float draw_x = x;
    if (align[0] == 'c') {
        draw_x = x - m.width / 2.0f;
    } else if (align[0] == 'r') {
        draw_x = x - m.width;
    }

    float draw_y = y - m.ascent;

    uint8_t r = _state.fill_r, g = _state.fill_g, b = _state.fill_b, a = _state.fill_a;

    for (int ci = 0; text[ci]; ci++) {
        int ch = (unsigned char)text[ci];
        if (ch < kFontFirstChar || ch > kFontLastChar) ch = '?';
        int idx = ch - kFontFirstChar;

        const uint8_t* glyph = font_8x16[idx];
        float gx = draw_x + ci * kFontW * scale;

        if (scale >= 0.9f && scale <= 1.1f) {
            int igx = (int)(gx + 0.5f);
            int igy = (int)(draw_y + 0.5f);
            for (int row = 0; row < kFontH; row++) {
                int screen_y = igy + row;
                if (!in_band(screen_y)) continue;
                uint8_t bits = glyph[row];
                if (bits == 0) continue;
                for (int col = 0; col < kFontW; col++) {
                    if (bits & (0x80 >> col)) {
                        put_pixel(igx + col, screen_y, r, g, b, a);
                    }
                }
            }
        } else {
            int sw = (int)(kFontW * scale + 0.5f);
            int sh = (int)(kFontH * scale + 0.5f);
            int igx = (int)(gx + 0.5f);
            int igy = (int)(draw_y + 0.5f);
            for (int py = 0; py < sh; py++) {
                int src_row = py * kFontH / sh;
                int screen_y = igy + py;
                if (!in_band(screen_y)) continue;
                uint8_t bits = glyph[src_row];
                if (bits == 0) continue;
                for (int px = 0; px < sw; px++) {
                    int src_col = px * kFontW / sw;
                    if (bits & (0x80 >> src_col)) {
                        put_pixel(igx + px, screen_y, r, g, b, a);
                    }
                }
            }
        }
    }
}

#endif /* HAS_FONT_ATLAS */

/* -------------------------------------------------------------------
 * Image pipeline — decode_image / draw_image / free_image (M5)
 *
 * Supported codecs on this tier (no-PSRAM heap budget):
 *   - BMP 24-bit BI_RGB (top-down or bottom-up)      -> RGB565
 *   - BMP 32-bit (BGRA)                              -> RGB565 + A8
 *   - CI16 raw sprite  ("CI16" u16 w u16 h, RGB565le) -> RGB565
 * PNG/JPEG are NOT decoded on-device (deferred; the offline bakers
 * emit BMP/CI16 for embedded targets).  Oversized images are refused.
 * ------------------------------------------------------------------- */

static constexpr size_t kMaxDecodedBytes = 120 * 1024;

static inline uint32_t rd_le32(const uint8_t* p) {
    return (uint32_t)p[0] | ((uint32_t)p[1] << 8) |
           ((uint32_t)p[2] << 16) | ((uint32_t)p[3] << 24);
}
static inline uint16_t rd_le16(const uint8_t* p) {
    return (uint16_t)p[0] | ((uint16_t)p[1] << 8);
}
static inline uint16_t pack565(uint8_t r, uint8_t g, uint8_t b) {
    return (uint16_t)(((r & 0xF8) << 8) | ((g & 0xFC) << 3) | (b >> 3));
}

ImageHandle ESP32Canvas::decode_image(const uint8_t* data, size_t len) {
    if (!data || len < 8) return nullptr;

    /* ---- CI16 raw sprite ---- */
    if (data[0] == 'C' && data[1] == 'I' && data[2] == '1' && data[3] == '6') {
        uint16_t w = rd_le16(data + 4);
        uint16_t h = rd_le16(data + 6);
        size_t need = (size_t)w * h * 2;
        if (w == 0 || h == 0 || len < 8 + need) return nullptr;
        if (need > kMaxDecodedBytes) {
            ESP_LOGW(TAG, "decode_image: CI16 %ux%u exceeds budget", w, h);
            return nullptr;
        }
        auto* img = static_cast<DecodedImage*>(malloc(sizeof(DecodedImage)));
        if (!img) return nullptr;
        img->w = w; img->h = h; img->alpha = nullptr;
        img->pix565 = static_cast<uint16_t*>(malloc(need));
        if (!img->pix565) { free(img); return nullptr; }
        const uint8_t* src = data + 8;
        for (size_t i = 0; i < (size_t)w * h; i++) {
            img->pix565[i] = rd_le16(src + i * 2);
        }
        return img;
    }

    /* ---- BMP ---- */
    if (data[0] == 'B' && data[1] == 'M' && len >= 54) {
        uint32_t px_off = rd_le32(data + 10);
        uint32_t dib = rd_le32(data + 14);
        if (dib < 40) return nullptr;
        int32_t w = (int32_t)rd_le32(data + 18);
        int32_t h_signed = (int32_t)rd_le32(data + 22);
        uint16_t bpp = rd_le16(data + 28);
        uint32_t compression = rd_le32(data + 30);
        bool top_down = h_signed < 0;
        int32_t h = top_down ? -h_signed : h_signed;

        if (w <= 0 || h <= 0 || w > 4096 || h > 4096) return nullptr;
        if (bpp != 24 && bpp != 32) return nullptr;
        if (compression != 0 && compression != 3 /* BITFIELDS, assume BGRA */)
            return nullptr;

        size_t bytes_pp = bpp / 8;
        size_t stride = ((size_t)w * bytes_pp + 3) & ~3u;
        if (px_off + stride * h > len) return nullptr;

        size_t need = (size_t)w * h * 2 + (bpp == 32 ? (size_t)w * h : 0);
        if (need > kMaxDecodedBytes) {
            ESP_LOGW(TAG, "decode_image: BMP %ldx%ld exceeds budget",
                     (long)w, (long)h);
            return nullptr;
        }

        auto* img = static_cast<DecodedImage*>(malloc(sizeof(DecodedImage)));
        if (!img) return nullptr;
        img->w = (uint16_t)w; img->h = (uint16_t)h;
        img->pix565 = static_cast<uint16_t*>(malloc((size_t)w * h * 2));
        img->alpha = (bpp == 32)
            ? static_cast<uint8_t*>(malloc((size_t)w * h)) : nullptr;
        if (!img->pix565 || (bpp == 32 && !img->alpha)) {
            free(img->pix565); free(img->alpha); free(img);
            return nullptr;
        }

        for (int32_t row = 0; row < h; row++) {
            int32_t src_row = top_down ? row : (h - 1 - row);
            const uint8_t* src = data + px_off + (size_t)src_row * stride;
            for (int32_t col = 0; col < w; col++) {
                const uint8_t* p = src + (size_t)col * bytes_pp;
                uint8_t b = p[0], g = p[1], r = p[2];
                size_t idx = (size_t)row * w + col;
                img->pix565[idx] = pack565(r, g, b);
                if (img->alpha) img->alpha[idx] = p[3];
            }
        }
        return img;
    }

    return nullptr;   /* undecodable — caller renders fallback */
}

void ESP32Canvas::draw_image(ImageHandle handle, float x, float y,
                             float w, float h) {
    auto* img = static_cast<DecodedImage*>(handle);
    if (!img || !img->pix565 || w <= 0 || h <= 0) return;

    int dx0 = (int)floorf(x);
    int dy0 = (int)floorf(y);
    int dx1 = (int)ceilf(x + w) - 1;
    int dy1 = (int)ceilf(y + h) - 1;

    /* Early band rejection */
    if (dy1 < _row_lo || dy0 > _row_hi) return;

    for (int row = dy0; row <= dy1; row++) {
        if (!in_band(row)) continue;
        /* Nearest-neighbor source row */
        int sy = (int)(((float)row + 0.5f - y) * img->h / h);
        if (sy < 0) sy = 0;
        if (sy >= img->h) sy = img->h - 1;
        const uint16_t* src_row = img->pix565 + (size_t)sy * img->w;
        const uint8_t* alpha_row =
            img->alpha ? img->alpha + (size_t)sy * img->w : nullptr;

        for (int col = dx0; col <= dx1; col++) {
            int sx = (int)(((float)col + 0.5f - x) * img->w / w);
            if (sx < 0) sx = 0;
            if (sx >= img->w) sx = img->w - 1;

            uint16_t c = src_row[sx];
            uint8_t a = alpha_row ? alpha_row[sx] : 255;
            if (a == 0) continue;

            uint8_t r = (c >> 8) & 0xF8; r |= r >> 5;
            uint8_t g = (c >> 3) & 0xFC; g |= g >> 6;
            uint8_t b = (c << 3) & 0xF8; b |= b >> 5;
            put_pixel(col, row, r, g, b, a);
        }
    }
}

void ESP32Canvas::free_image(ImageHandle handle) {
    auto* img = static_cast<DecodedImage*>(handle);
    if (!img) return;
    free(img->pix565);
    free(img->alpha);
    free(img);
}
